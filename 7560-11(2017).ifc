Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2019-02-20T16:40:10
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20150714_1515(x64) - Exporter 16.6.0.0 - Alternate UI 16.6.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Wed Feb 20 16:40:10 2019 * Host: Avocado-PC * Database: C:\Users\Avocado\AppData\Local\Temp\{2B144537-1365-4923-867A-E60F7ADA0CEE}\ifc * Database version: 5507 * Database creation date: Wed Feb 20 16:40:09 2019 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Wed Feb 20 16:40:09 2019 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Wed Feb 20 16:40:09 2019 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 30, 344238; RefLongitude: -71, -3, -35, -194702; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes

# IfcFlowController: 7560-11 Shower faucet, 7560-11(2017):7560-11 Shower faucet:329920
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions(Type) - NominalDepth: 145.6 mm; NominalHeight: 77.5 mm; NominalWidth: 370.6 mm
Type - General(Type) - Author: Convergo AB; BIMObjectName: 7560-11(2017); ConvergoRefNr: 0087-1902-0013-FI; ManufacterURL: http://www.oras.com/; ManufacturerName: Oras; NBSDescription: Water supply fittings for baths; NBSReference: 45-35-70/315; ProductInformation: n/a; Revision: n/a; Uniclass2: Pr_40_30_96_81; Uniclass2015Description: Shower thermostatic water supply sets; Uniclass2015Reference: Pr_40_20_87_81; Version: 1; VersionDate: 19/02/2019
Type - Green Building Properties(Type) - Backflow Prevention EN1717: EB; Customs Code: 84818011; EAN Number: 6414150082894; EN Standard: EN 1111; LVI Number: 6310838; Noise Class: I (ISO 3822) Oras lab.; NRF Number: 4200548; RSK Number: 8351137; VVS Number: 722785124
Type - Identity Data(Type) - 2D/3D/BIM Files URL: http://static.oras.com/bim/7560-11; Catalog Drawing URL: http://static.oras.com/catdrw/7560-11; Class: Thermostatic; Dimension Drawing URL: http://static.oras.com/dimdrw/7560-11; FDV Document URL: http://www.oras.com/datasheet/7560-11/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/7560-11; Group: Shower faucets; Long Marketing: Thermostatic shower faucet with easy-to-use control handles. Temperature limiter in the handle. Spacious shelf made of safety glass. The faucet is equipped with straight couplings with stop valves, litter filters and non-return valves.; Manufacturer: Oras; Market: INT;FIN;NOR;SWE;DNK;EST;LTU;LVA;UKR; Model: 7560-11 Shower faucet; Name_en: 7560-11 Shower faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Package external Dimensions: 415 x 183 x 147; Package Weight: 3.6 kg; Product Code: 7560-11; Product Datasheet: http://www.oras.com/datasheet/7560-11/en; Product Family: Oras Esteta; Product Image URL: http://static.oras.com/image/7560-11; Product URL: http://static.oras.com/7560-11; Type Name: 7560-11 Shower faucet
Type - Materials and Finishes(Type) - FaucetMainMaterial: Brass
Type - Mechanical(Type) - Advanced Features: Safety glass; Connection: Ball eccentric union; Connection Size: G1/2; Flow Rate At 300kPa: 0.00812237 m3/s; Installation and Maintenance: http://static.oras.com/manual/7560-11; Installation Type: Wall-mounted; Installation Width: CC150 mm; Max. Hot Water Supply: 80 kg/K/s3; Pressure Loss With Flow 02ls: 230000 Pa; Spare Parts: http://static.oras.com/sp/7560-11; Temperature: Thermostatic temperature control;Thermostatic safety stop at 38°C;THERMO COOL
Type - Other(Type) - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Bathroom, shower; CodePerformance: n/a; Color: Chrome/White; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 7560-11(2017); Features: Thermostatic; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 7560-11; Name: 7560-11 Shower faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 370x145x80 mm; SustainabilityPerformance: n/a; WarrantyDescription: https://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Pset_ManufacturerTypeInformation - ModelReference: 7560-11; Manufacturer: Oras
Pset_DistributionFlowElementCommon - Reference: 7560-11 Shower faucet
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0959438 m2; ConnectorDirection: 0; ConnectorDirectionNote: 0-Up II 1-Back II 2-Down; InletConnectionSize: 15 mm; InletDistance: 150 mm; OutletAngle: 0 deg; Volume: 0.00419267 m3
Identity Data - Mark: 9
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 7560-11(2017): 7560-11 Shower faucet; Family and Type: 7560-11(2017): 7560-11 Shower faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 7560-11(2017): 7560-11 Shower faucet; Type Id: 7560-11(2017): 7560-11 Shower faucet; WarrantyStartDate: n/a
Phasing - Phase Created: New Construction
